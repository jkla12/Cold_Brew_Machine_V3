# Keil uVision project Project.uvprojx, settings and files
target GD32F30X_CL (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: GD32F307RC GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.2.3
  cpu: IROM(0x08000000,0x040000) IRAM(0x20000000,0x018000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F30X_CL
  c include: ..\Firmware\CMSIS;..\Firmware\CMSIS\GD\GD32F30x\Include;..\Firmware\GD32F30x_standard_peripheral\Include;..\
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Application
    ../: gd32f30x_it.c main.c systick.c
  group CMSIS
    ../Firmware/CMSIS/GD/GD32F30x/Source/: system_gd32f30x.c
  group Peripherals
    ../Firmware/GD32F30x_standard_peripheral/Source/: gd32f30x_adc.c gd32f30x_bkp.c gd32f30x_can.c gd32f30x_crc.c gd32f30x_ctc.c gd32f30x_dac.c gd32f30x_dbg.c gd32f30x_dma.c gd32f30x_enet.c gd32f30x_exmc.c gd32f30x_exti.c gd32f30x_fmc.c gd32f30x_fwdgt.c gd32f30x_gpio.c gd32f30x_i2c.c gd32f30x_misc.c gd32f30x_pmu.c gd32f30x_rcu.c gd32f30x_rtc.c gd32f30x_sdio.c gd32f30x_spi.c gd32f30x_timer.c gd32f30x_usart.c gd32f30x_wwdgt.c
  group Startup
    ../Firmware/CMSIS/GD/GD32F30x/Source/ARM/: startup_gd32f30x_hd.s
  group User
    ../User/uart/: uart.c
    ../User/Button/: button.c dr_button_api.c dr_button_reg.c
    ../User/LED/: led.c
    ../DSP/: arm_cortexM4lf_math.lib
    ../User/relay/: relay.c
    ../User/timer/: timer.c
    ../User/work/: work.c waterLevel.c coffeeMake.c drain.c sanit.c teaMake.c wash.c waterTap.c
    ../User/eeprom/: eeprom.c
    ../User/Dial/: dial.c
    ../User/iic/: iic.c
    ../User/ADC/: adc.c
    ../User/filter/: app_filter.c
    ../User/CJson/: cJSON.c
    ../User/DEBUG/: debug.c
  group LCD
    ../User/uart_LCD/: lcd_cmd_queue.c lcd_data_process.c uart_lcd.c
  group WIFI
    ../User/wifi/: app_wifi.c bsp_wifi.c app_wifi_set.c app_mqtt.c
  group eLog
    ../User/easyLog/: elog.c elog_async.c elog_buf.c elog_port.c elog_utils.c
  group HMI
    ../User/HMI/: coffeeExtractionPage.c coffeeSetPage.c deviceInfoPage.c drainPage.c errPage.c languagePage.c productionDataPage.c sanitPage.c teaExtractionPage.c teaSetPage.c timeSetPage.c washPage.c waterTapPage.c wifiSetPage.c
target GD32F30X_XD (ARM-ADS)
  device: GD32F303RK GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.2.3
  cpu: IRAM(0x20000000,0x018000) IROM(0x08000000,0x0300000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F30X_XD
  c include: ..\..\Firmware\CMSIS;..\..\Firmware\CMSIS\GD\GD32F30x\Include;..\..\Firmware\GD32F30x_standard_peripheral\Include;..\..\Utilities;..\
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x300000
  memory RVCT9: RAM 0x20000000 size 0x18000
target GD32F30X_HD (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F303RC GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.2.3
  cpu: IRAM(0x20000000,0x0C000) IROM(0x08000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F30X_HD,MATH_303,ARM_MATH_CM4,__TARGET_FPU_VFP,__FPU_USED,__FPU_PRESENT,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c include: ..\Firmware\CMSIS;..\Firmware\CMSIS\GD\GD32F30x\Include;..\Firmware\GD32F30x_standard_peripheral\Include;..\;..\User\uart;..\User\ADC;..\User\Button;..\User\LED;..\DSP;..\User\relay;..\User\timer;..\User\work;..\User\eeprom;..\User\uart_LCD;..\User\Dial;..\User\iic;..\User\wifi;..\User\easyLog;..\User\HMI;..\User\filter;..\User\CJson;..\User\DEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
software components: CMSIS:CORE 5.6.0
